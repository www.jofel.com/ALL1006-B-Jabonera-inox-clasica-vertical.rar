Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Accessories_Jofel_Inox-soap-dispenser-classic-range-vertic.ifc
Time: 2019-05-14T10:29:49
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement, Inox soap dispenser classic range vertical
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Inox soap dispenser classic range vertical; SKU (BO_prodsku): inox_soap_dispenser_classic_vertical; ManufacturName (BO_Manufac): Jofel; BrandUrl (BO_brandurl): http://jofel.com; ProductFamily (BO_prodfam): Bath accessories; ProductGroup (BO_prodgroup): Luxury; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 90; Height (BO_height): 166; Depth (BO_depth): 112; Weight (BO_weight): 0.415; QR (BO_boqrurl): http://bimobject.com/jofel/product/inox_soap_dispenser_classic_vertical; ProductDataUrl (BO_prodaturl): bimobject.com/jofel/product/inox_soap_dispenser_classic_vertical; ProductUrl (BO_producturl): http://jofel.com/en/dosificador-de-jabon-vertical-clasica.html; TechnicalDescription (BO_techcert): http://jofel.com/media/fichas/en/ALL1006.pdf; GtinCode (BO_gtin): 8427950304200; MaterialMain (BO_mainmat): Chrome; MaterialSecondary (BO_secmat): Chrome; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Accessories; BimObjectCategoryCode (BO_bocat_code): sanitary-accessories1; IfcClassification (BO_ifcclas): Furnishing Element; UnspcCode (BO_unspc): 30181505; Uniclass14Code (BO_uniclass_1_4_code): L8246; Uniclass14Description (BO_uniclass_1_4_desc): Soap holders/dispensers; Uniclass20Code (BO_uniclass_2_0_code): PR-35-76-80; Uniclass20Description (BO_uniclass_2_0_desc): Soap Dispensers; Uniclass2015Code (BO_uniclass2015_code): Pr_40_70_22_81; Uniclass2015Description (BO_uniclass2015_desc): Soap dispensers; NBSReference (BO_nbs_ref): 35-76-80; NBSReferenceDescription (BO_nbs_desc): Soap Dispensers; OmniClassCode (BO_omniclass_code): 23-31 25 29 13; OmniClassDescription (BO_omniclass_name): Hand Soap Dispensers; MasterFormat2014Code (BO_masterformat2014_code): 10 28 13; MasterFormat2014Description (BO_masterformat2014_name): Toilet Accessories; RegionEurope (BO_europe): AL, AT, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FR, GB, GR, HR, HU, IE, IT, LT, LU, LV, MD, ME, MK, NL, NO, PL, PT, RO, RS, RU, SE, SI, SK, UA; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, GF, GY, PE, PY, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BT, CN, GE, ID, IN, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MY, NP, PH, PK, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AU, FJ, NC, NZ, PG, SB, TL, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, DJ, DZ, EH, ER, ET, GA, GH, GN, GQ, GW, KE, LR, LS, LY, MA, MG, ML, MR, MW, MZ, NA, NE, NG, RW, SD, SL, SN, SO, SS, SZ, TD, TG, TN, TZ, UG, ZA, ZM, ZW
